Commit message: Decrease plane dimensions

File: src/pybullet/pybullet_description/models/urdf/simpleplane.urdf (robot description, URDF)
Before this commit: robot simpleplane, 1 links, 0 joints
Links:
- link plane: geometry collision box size=3 3 0.01; visual box size=3 3 0.01
